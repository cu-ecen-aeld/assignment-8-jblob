## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
    bool "ldd modules"
    help
        Build and install scull and misc kernel modules
```
